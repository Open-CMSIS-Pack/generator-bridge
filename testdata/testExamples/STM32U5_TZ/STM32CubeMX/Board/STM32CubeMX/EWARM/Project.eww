<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32CubeMX_NS.ewp</path>
  </project><project>
    <path>$WS_DIR$\STM32CubeMX_S.ewp</path>
  </project>
  <batchBuild />
</workspace>
