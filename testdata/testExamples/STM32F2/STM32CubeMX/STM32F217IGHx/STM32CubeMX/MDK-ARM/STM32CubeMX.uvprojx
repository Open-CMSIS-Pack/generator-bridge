# Keil uVision project STM32CubeMX.uvprojx, settings and files
target STM32CubeMX (ARM-ADS)
  device: STM32F217IGHx STMicroelectronics
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32CubeMX +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F217xx
  c include: ../Inc;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../Drivers/CMSIS/Include
  group Application/MDK-ARM
    ./: startup_stm32f217xx.s
  group Application/User
    ../Src/: main.c gpio.c eth.c i2c.c sdio.c spi.c usart.c usb_otg.c stm32f2xx_it.c stm32f2xx_hal_msp.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_eth.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c stm32f2xx_hal_i2c.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal_sd.c stm32f2xx_hal_mmc.c stm32f2xx_hal_spi.c stm32f2xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
software components: CMSIS:CORE 4.3.0
