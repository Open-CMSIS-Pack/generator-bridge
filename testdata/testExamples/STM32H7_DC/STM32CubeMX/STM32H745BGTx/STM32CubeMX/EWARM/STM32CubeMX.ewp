# IAR project STM32CubeMX.ewp, settings and files
configuration STM32CubeMX_CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H745BG_CM4 ST STM32H745BG_CM4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32H745xx
  ICCARM.CCIncludePath2: ../CM4/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32CubeMX_CM4.hex
  ILINK.IlinkOutputFile: STM32CubeMX_CM4.out
  ILINK.IlinkIcfFile: stm32h745xg_flash_CM4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32CubeMX_CM7 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H745BG_CM7 ST STM32H745BG_CM7
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H745xx
  ICCARM.CCIncludePath2: ../CM7/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  OBJCOPY.OOCOutputFile: STM32CubeMX_CM7.hex
  ILINK.IlinkOutputFile: STM32CubeMX_CM7.out
  ILINK.IlinkIcfFile: stm32h745xg_flash_CM7.icf
  group Application/EWARM
    ./: startup_stm32h745xx_CM4.s startup_stm32h745xx_CM7.s
  group Application/User/CM4
    ../CM4/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/CM7
    ../CM7/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
