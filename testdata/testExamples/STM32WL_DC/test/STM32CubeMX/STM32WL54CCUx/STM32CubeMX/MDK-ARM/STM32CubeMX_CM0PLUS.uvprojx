# Keil uVision project STM32CubeMX_CM0PLUS.uvprojx, settings and files
target STM32CubeMX_CM0PLUS (6140001::V6.14.1::ARMCLANG)
  device: STM32WL54CCUx:CM0P STMicroelectronics
  cpu: IRAM(0x20004000-0x20007FFF) IRAM2(0x2000C000-0x2000FFFF) IROM(0x8020000-0x803FFFF)  CLOCK(12000000) CPUTYPE("Cortex-M0+") TZ
  output: STM32CubeMX_CM0PLUS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM0PLUS,STM32WL54xx,USE_HAL_DRIVER
  c include: ../CM0PLUS/Inc;../Drivers/STM32WLxx_HAL_Driver/Inc;../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../Drivers/CMSIS/Include
  scatter file: stm32wl54xx_flash_cm0plus.sct
  group Application/MDK-ARM
    ./: startup_stm32wl54xx_cm0plus.s
  group Application/User/CM0PLUS
    ../CM0PLUS/Src/: main.c stm32wlxx_it.c stm32wlxx_hal_msp.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ./: 
    ../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c
software components: CMSIS:CORE 4.3.0
