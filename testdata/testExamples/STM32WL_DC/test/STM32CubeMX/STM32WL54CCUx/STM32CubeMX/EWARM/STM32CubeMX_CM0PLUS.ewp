# IAR project STM32CubeMX_CM0PLUS.ewp, settings and files
configuration STM32CubeMX_CM0PLUS (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL54CC_M0+ ST STM32WL54CC_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CORE_CM0PLUS; STM32WL54xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ../CM0PLUS/Inc; ../Drivers/STM32WLxx_HAL_Driver/Inc; ../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32CubeMX_CM0PLUS.hex
  ILINK.IlinkOutputFile: STM32CubeMX_CM0PLUS.out
  ILINK.IlinkIcfFile: stm32wl54xx_flash_cm0plus.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl54xx_cm0plus.s
  group Application/User/CM0PLUS
    ../CM0PLUS/Src/: main.c stm32wlxx_it.c stm32wlxx_hal_msp.c
  group Drivers/STM32WLxx_HAL_Driver
    ../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
