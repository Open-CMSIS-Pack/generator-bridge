<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32CubeMX_CM4.ewp</path>
  </project><project>
    <path>$WS_DIR$\STM32CubeMX_CM0PLUS.ewp</path>
  </project>
  <batchBuild />
</workspace>
